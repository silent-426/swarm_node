## src/modules/control_node/Kconfig
```kconfig
menuconfig MODULES_CONTROL_NODE
	bool "control_node"
	default n
	---help---
		Enable support for control_node
```
